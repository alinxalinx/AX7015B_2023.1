SRC_URI += "file://user_2018-09-05-15-21-00.cfg \
            file://user_2018-09-06-11-13-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

